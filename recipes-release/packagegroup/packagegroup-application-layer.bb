SUMMARY = "Custom package group for application layer"

PACKAGE_ARCH = "${APPLICATION_LAYER_ARCH}"
LICENSE = "MIT"

inherit packagegroup

PV = "2.1"
PR = "r0"
